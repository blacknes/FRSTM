# Keil uVision project STM32f103ZET_FreeRTOS.uvproj, settings and files
target FRSTM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103ZET_FreeRTOS +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\STM32FLib\CMSIS\CoreSupport;.\STM32FLib\CMSIS\DeviceSupport;.\STM32FLib\inc;.\STM32FLib\USER;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./STM32FLib/USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group CMSIS
    ./STM32FLib/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ./STM32FLib/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./STM32FLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./STM32FLib/Startup/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
